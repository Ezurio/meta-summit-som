OS_RELEASE_FIELDS += "BUILD_ID"

SUMMIT_VERSION ?= "0.0.0.0"
SUMMIT_RELEASE_STRING ?= "Summit Linux development build 0.0.0.0"

NAME:summitsom = "Summit Linux"
VERSION:summitsom = "${SUMMIT_RELEASE_STRING}"
VERSION_ID:summitsom = "${SUMMIT_VERSION}"
PRETTY_NAME:summitsom = "${SUMMIT_RELEASE_STRING}"
