PACKAGECONFIG = "curl"
