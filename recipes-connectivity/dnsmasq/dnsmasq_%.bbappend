SYSTEMD_AUTO_ENABLE:summitsom = "disable"
INITSCRIPT_PARAMS:summitsom = "disable"

PACKAGECONFIG:append:summitsom = " dbus"
