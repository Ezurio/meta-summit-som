FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-wpa-cli-nm.patch"
