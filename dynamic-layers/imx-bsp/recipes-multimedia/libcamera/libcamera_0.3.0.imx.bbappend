# Keep the i.MX libcamera package separate from same-tune builds for other machines.
PACKAGE_ARCH = "${MACHINE_ARCH}"
